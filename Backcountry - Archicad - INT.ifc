Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, SurfaceGeometryAddOnView], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: On], Option [Export geometries that Participates in Collision Detection only: On], Option [Split complex elements: Off], Option [Material Preservation: Explode all], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: C:\Users\Stas\Desktop\28\GLO\Backcountry_INT_metric SDP 28.ifc
Time: 2026-05-18T16:48:34
Author: Architect
Organization: Building Designer Office
Written by: DDS_IFC v3.0
Made in: Graphisoft - Archicad - 28.3.3
Authorization: The authorising person

# IfcSite, Site
RefLatitude: 47, 33, 34, 920000; RefLongitude: 19, 3, 17, 172000; RefElevation: 0 mm

# IfcBuildingStorey (2)
In: Building
Name | Elevation (mm)
Second Floor | 3250
First Floor | 0

# IfcBeam: GENERIC - STRUCTURAL 51 x 203, BMR - 113
In: Second Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_BeamCommon - Span: 1500 mm; Slope: 0 deg; Reference: GENERIC - STRUCTURAL 51 x 203

# IfcBeam: Tile - Wall 10 x 1120 (6)
In: Second Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: Tile - Wall
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Pset_BeamCommon - Slope: 0 deg; Reference: Tile - Wall 10 x 1120
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | Span (mm)
BMR - 113 | 1125.66
BMR - 113 | 1088.28
BMR - 113 | 804.776
BMR - 113 | 1600
BMR - 113 | 1009.95
BMR - 113 | 75.0294

# IfcBeam: Tile - Wall 10 x 135 (2)
In: Second Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: Tile - Wall
Pset_BeamCommon - Slope: 0 deg; Reference: Tile - Wall 10 x 135
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | Span (mm)
BMR - 041 | 1200
BMR - 041 | 1500

# IfcBeam: Tile - Wall 10 x 205 (2)
In: Second Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: Tile - Wall
Pset_BeamCommon - Slope: 0 deg; Reference: Tile - Wall 10 x 205
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | Span (mm)
BMR - 112 | 1670
BMR - 113 | 2390

# IfcBeam: Tile - Wall 10 x 2465 (4)
In: Second Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: Tile - Wall
Pset_BeamCommon - Slope: 0 deg; Reference: Tile - Wall 10 x 2465
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | Span (mm)
BMR - 004 | 1065
BMR - 004 | 1650.01
BMR - 004 | 149.255
BMR - 004 | 1470.02

# IfcBeam: Tile - Wall 10 x 370, BMR - 041
In: Second Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: Tile - Wall
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Pset_BeamCommon - Span: 1244.99 mm; Slope: 0 deg; Reference: Tile - Wall 10 x 370
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBeam: Tile - Wall 10 x 380 (5)
In: Second Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: Tile - Wall
Pset_BeamCommon - Slope: 0 deg; Reference: Tile - Wall 10 x 380
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | Span (mm)
BMR - 041 | 840.3
BMR - 041 | 1004.93
BMR - 041 | 635
BMR - 041 | 854.744
BMR - 041 | 1000.07

# IfcBeam: Tile - Wall 10 x 420 (2)
In: Second Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: Tile - Wall
Pset_BeamCommon - Slope: 0 deg; Reference: Tile - Wall 10 x 420
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | Span (mm)
BMR - 114 | 1835
BMR - 113 | 1630.02

# IfcBeam: Tile - Wall 15 x 420, BMR - 115
In: Second Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: Tile - Wall
Pset_BeamCommon - Span: 635.042 mm; Slope: 0 deg; Reference: Tile - Wall 15 x 420
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBeam: Tile - Wall 5 x 2555 (3)
In: First Floor
Type - PredefinedType: BEAM
Classification: Beam (Archicad Classification); Material: Tile - Wall
Pset_BeamCommon - Slope: 0 deg; Reference: Tile - Wall 5 x 2555
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | Span (mm)
BMR - 006 | 1475
BMR - 007 | 800
BMR - 005 | 800

# IfcBuildingElementPart (103)
Name | In | Material
11 x Wood - Trim | First Floor | Wood - Trim
32 x Timber - Floor | First Floor | Timber - Floor
60 x Wood - Trim | Second Floor | Wood - Trim

# IfcBuildingElementProxy: Ceiling Ventillator (3)
In: Second Floor
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Color - White (2)
Material: Color - White
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
OBJ-03 | First Floor
OBJ-03 | Second Floor

# IfcBuildingElementProxy: Door (24)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
9 x DOO - 001 | First Floor
15 x DOO - 001 | Second Floor

# IfcBuildingElementProxy: Double Door (2)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
DOO - 001 | First Floor
DOO - 001 | Second Floor

# IfcBuildingElementProxy: Double Sash Window (4)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
3 x WD - 001 | First Floor
WD - 001 | Second Floor

# IfcBuildingElementProxy: Fluorescent Lamp (2)
In: Second Floor
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL, MO-02
In: First Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 10, SLA - 010
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 100, SLA - 016
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 114 (2)
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | Renovation Status
SW - 039 | Existing
SW - 039 | New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 115 (41)
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In | Renovation Status
SW - 059 | First Floor | New
SW - 016 | First Floor | New
SW - 058 | First Floor | New
SW - 015 | First Floor | New
SW - 054 | First Floor | New
2 x SW - 057 | First Floor | New
SW - 146 | First Floor | New
SW - 066 | First Floor | New
2 x SW - 051 | First Floor | New
SW - 017 | First Floor | New
W-17 | First Floor | New
W-16 | First Floor | New
SW - 018 | First Floor | New
SW - 132 | Second Floor | New
SW - 084 | Second Floor | New
SW - 015 | Second Floor | New
W-12 | Second Floor | New
SW - 115 | Second Floor | New
SW - 100 | Second Floor | New
2 x W-03 | Second Floor | New
SW - 101 | Second Floor | New
SW - 135 | Second Floor | New
SW - 106 | Second Floor | New
SW - 137 | Second Floor | New
SW - 102 | Second Floor | Existing
SW - 075 | Second Floor | New
2 x SW - 110 | Second Floor | New
SW - 078 | Second Floor | New
SW - 138 | Second Floor | New
SW - 107 | Second Floor | New
SW - 082 | Second Floor | New
SW - 106 | Second Floor | Existing
SW - 117 | Second Floor | New
SW - 108 | Second Floor | Existing
SW - 131 | Second Floor | New
SW - 103 | Second Floor | Existing
SW - 119 | Second Floor | New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 120 (3)
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | Renovation Status
SLA - 014 | Existing
2 x SW - 130 | New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 125 (2)
In: Second Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name
SLA - 011
SLA - 019

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 140 (4)
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
SW - 052 | First Floor
SW - 077 | Second Floor
SW - 104 | Second Floor
SW - 126 | Second Floor

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 150 (9)
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In | Renovation Status
SW - 067 | First Floor | New
SLA - 014 | Second Floor | Existing
2 x SLA - 016 | Second Floor | New
SLA - 002 | Second Floor | New
SLA - 006 | Second Floor | New
SLA - 008 | Second Floor | New
SLA - 018 | Second Floor | New
SLA - 017 | Second Floor | New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 155 (2)
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
SLA - 003 | First Floor
SLA - 007 | Second Floor

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 160 (2)
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In
SW - 037 | First Floor
SLA - 004 | Second Floor

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 165 (30)
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In | Renovation Status
SW - 035 | First Floor | New
SW - 036 | First Floor | New
SW - 056 | First Floor | New
SW - 055 | First Floor | New
SW - 086 | Second Floor | New
2 x SW - 102 | Second Floor | New
2 x SW - 093 | Second Floor | New
SW - 118 | Second Floor | New
SW - 116 | Second Floor | New
SW - 105 | Second Floor | New
SW - 080 | Second Floor | New
2 x SW - 123 | Second Floor | New
2 x SW - 088 | Second Floor | New
SW - 099 | Second Floor | New
SW - 120 | Second Floor | New
SW - 145 | Second Floor | Existing
SW - 109 | Second Floor | New
SW - 112 | Second Floor | New
SW - 087 | Second Floor | New
SW - 136 | Second Floor | New
SW - 134 | Second Floor | New
SW - 121 | Second Floor | New
SW - 129 | Second Floor | New
SW - 076 | Second Floor | New
SW - 098 | Second Floor | New
SW - 122 | Second Floor | New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 170 (2)
In: Second Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name
SW - 130
SW - 081

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 190 (4)
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In
SW - 044 | First Floor
SW - 102 | Second Floor
SLA - 014 | Second Floor
SLA - 010 | Second Floor

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 20 (2)
In: First Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name
SLA - 008
SLA - 007

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 200 (2)
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
SW - 081
SLA - 012

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 205 (5)
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
SW - 073 | First Floor
SW - 116 | Second Floor
2 x SW - 128 | Second Floor
SW - 124 | Second Floor

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 210 (2)
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
SW - 020 | First Floor
SW - 018 | Second Floor

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 215 (5)
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
SW - 024 | First Floor
SW - 090 | Second Floor
SW - 092 | Second Floor
SW - 129 | Second Floor
SW - 111 | Second Floor

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 230 (2)
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | Renovation Status
SW - 086 | New
SLA - 019 | Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 240, SW - 108
In: Second Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 25 x 1100, BMR - 064
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 25 x 965, BMR - 065
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 25 x 980, BMR - 068
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 250, SW - 025
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 255 (3)
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In | Renovation Status
SLA - 009 | First Floor | Existing
SW - 016 | First Floor | New
SW - 099 | Second Floor | New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 265, SW - 021
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 280 (2)
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | Renovation Status
SLA - 017 | Existing
SW - 089 | New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 285, SLA - 005
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 320 (2)
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
SW - 064
SW - 019

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 325, SW - 048
In: First Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 350 (2)
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
SW - 026
SW - 063

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 360, SLA - 003
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 365, SW - 051
In: First Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 385, SW - 014
In: First Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 400, SLA - 013
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 425, SW - 020
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 455, SW - 068
In: First Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 455 x 510, C-01
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 485 x 760, C-01
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 495, SLA - 009
In: Second Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 50 (2)
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In
SLA - 005 | First Floor
SLA - 014 | Second Floor

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 50 x 205, BMR - 066
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 510 (2)
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
SLA - 011
SLA - 013

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 511, SLA - 015
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 515, SW - 022
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 520, SW - 053
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 565, SW - 053
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 608 x 5, BMR - 069
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 660, SLA - 012
In: Second Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 685, SLA - 002
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 75, SLA - 019
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 80, SLA - 006
In: First Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 80 x 200, BMR - 064
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: GENERIC - STRUCTURAL 90, SW - 014
In: Second Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: GENERIC - STRUCTURAL Polygonal (2)
In: Second Floor
Material: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name
SW - 127
SW - 079

# IfcBuildingElementProxy: Generic Floor/Ceiling Slab 150mm 150, S-01
In: First Floor
Material: GENERIC - STRUCTURAL
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Pendant Lamp (7)
In: Second Floor
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Railing Type (11)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
RAILING - 001 | First Floor
RAILING - 003 | First Floor
7 x RAILING - 001 | Second Floor
2 x RA-03 | Second Floor

# IfcBuildingElementProxy: Recessed Spot (52)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
26 x L-03 | First Floor
26 x L-03 | Second Floor

# IfcBuildingElementProxy: Shower Door, OBJ-32
In: Second Floor
Classification: Building Element Proxy (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Single-Hung Window (9)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In
2 x WD - 001 | First Floor
7 x WD - 001 | Second Floor

# IfcBuildingElementProxy: Sliding Door (3)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
DOO - 001 | First Floor
2 x DOO - 001 | Second Floor

# IfcBuildingElementProxy: Smoke and Heat Detector (5)
Classification: Building Element Proxy (Archicad Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In
3 x FU - 009 | First Floor
2 x FU - 009 | Second Floor

# IfcBuildingElementProxy: Stair Type, STAIR-30
In: First Floor
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Wall Lamp (6)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In
4 x L-17 | First Floor
2 x L-17 | Second Floor

# IfcBuildingElementProxy: Wall Spotlight (4)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In | Renovation Status
L-11 | First Floor | Existing
3 x L-11 | Second Floor | New

# IfcBuildingElementProxy: Window (17)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In
WD - 001 | First Floor
16 x WD - 001 | Second Floor

# IfcBuildingElementProxy: Wood - Trim 30, SLA - 015
In: Second Floor
Material: Wood - Trim
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcDistributionFlowElement: Basin, OBJ-24
In: Second Floor
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Distribution Flow Element (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcDistributionFlowElement: Bathtub, OBJ-17
In: First Floor
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Distribution Flow Element (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcDistributionFlowElement: Ceiling Grille (12)
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Distribution Flow Element (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In | Renovation Status
3 x FU - 007 | First Floor | Existing
5 x FU - 013 | First Floor | New
4 x FU - 007 | Second Floor | Existing

# IfcDistributionFlowElement: Freestanding Bathtub, OBJ-19
In: Second Floor
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Distribution Flow Element (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcDistributionFlowElement: Hood, FU - 017
In: Second Floor
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Distribution Flow Element (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcDistributionFlowElement: Rect Floor Register (7)
In: Second Floor
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Distribution Flow Element (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcDistributionFlowElement: Sidewall Grille (7)
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Distribution Flow Element (Archicad Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In
FU - 004 | First Floor
6 x FU - 004 | Second Floor

# IfcDistributionFlowElement: WC (3)
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Distribution Flow Element (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
OBJ-29 | First Floor
2 x OBJ-29 | Second Floor

# IfcDistributionFlowElement: Washer (2)
In: Second Floor
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Distribution Flow Element (Archicad Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcFlowController: Outlet 1 US (90)
Classification: Switching Device (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
49 x OBJ-05 | First Floor
41 x OBJ-05 | Second Floor

# IfcFlowController: Switch US (33)
Classification: Switching Device (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
6 x OBJ-09 | First Floor
27 x OBJ-09 | Second Floor

# IfcFurnishingElement: Base Cabinet Block (28)
Classification: Furniture (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | In | Renovation Status
3 x FU - 005 | First Floor | Existing
19 x FU - 005 | Second Floor | Existing
6 x FU - 004 | Second Floor | New

# IfcFurnishingElement: Base Cabinet Corner L, FU - 006
In: Second Floor
Classification: Furniture (Archicad Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcFurnishingElement: Oven Built-in (2)
In: Second Floor
Classification: Furniture (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
OBJ-20
OBJ-19

# IfcFurnishingElement: Range Gas, FU - 017
In: Second Floor
Classification: Furniture (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: Refrigerator, FU - 018
In: Second Floor
Classification: Furniture (Archicad Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcFurnishingElement: Standing Cabinet Block (2)
In: Second Floor
Classification: Furniture (Archicad Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model

# IfcFurnishingElement: Trash Compactor Built-in, FU - 029
In: Second Floor
Classification: Furniture (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: Wall Cabinet Block (19)
In: Second Floor
Classification: Furniture (Archicad Classification)
Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model
Name | Renovation Status
7 x FU - 007 | Existing
6 x FU - 008 | New
6 x FU - 005 | New

# IfcOpeningElement (80)
Name | In
OP - 001 | First Floor | Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model; AC_Pset_RenovationAndPhasing - Renovation Status: New
2 x OP-10 | First Floor | Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
11 x DOO - 001 | First Floor
6 x WD - 001 | First Floor
DOO - 011 | First Floor
3 x DOO - 005 | Second Floor
OP-11 | Second Floor | Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model; AC_Pset_RenovationAndPhasing - Renovation Status: New
18 x DOO - 001 | Second Floor
DOO - 006 | Second Floor
OP-12 | Second Floor | Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
2 x OP-17 | Second Floor | Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
24 x WD - 001 | Second Floor
2 x DOO - 004 | Second Floor
OP-11 | Second Floor | Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
2 x DOO - 003 | Second Floor
DOO - 002 | Second Floor
OP-16 | Second Floor | Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model; AC_Pset_RenovationAndPhasing - Renovation Status: New
OP-16 | Second Floor | Pset_DesignOptions - Design Option Set: Main Model; Design Option: Main Model; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
DOO - 011 | Second Floor
